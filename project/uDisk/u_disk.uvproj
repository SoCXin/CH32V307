# Keil uVision project u_disk.uvproj, settings and files
target qitas (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: u_disk +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\559&8模拟U盘
  group user
    ./: SPI0Flash.C
